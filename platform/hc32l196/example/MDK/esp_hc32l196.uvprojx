# Keil uVision project esp_hc32l196.uvprojx, settings and files
target esp_hc32l196_Release (6100001::V6.10.1::.\ARMCLANG)
  device: HC32L196PCTA HDSC
  pack: HDSC.HC32L19x.1.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: esp_hc32l196 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\source;..\..\ddl\mcu\common;..\..\ddl\driver\inc;..\..\..\..\host;..\..\..\..\host\port\hc32l19x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep=*Handler
  group startup
    ./: startup_hc32l19x.s
  group mcu_common
    ../../ddl/mcu/common/: system_hc32l19x.c interrupts_hc32l19x.c
  group ddl_driver
    ../../ddl/driver/src/: ddl.c sysctrl.c gpio.c uart.c
  group host_esp
    ../../../../host/: esp_port.c esp_link.c esp_client.c
    ../../../../host/port/hc32l19x/: esp_port_hc32l19x.c
  group app
    ../source/: main.c ddl_device.h
  group docs
    ../../: README.md
software components: CMSIS:CORE 4.1.0
